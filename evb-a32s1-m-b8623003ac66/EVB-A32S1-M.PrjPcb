# Altium project EVB-A32S1-M.PrjPcb
DrawnBy: Dennis C. M.; CompanyName: Dennis Micro Computers; Author: Dennis C. M.
1 sheet, 0 parts. Net scope: global (net labels, ports and power ports of the same name join across sheets).

## Sheet Power.SchDoc
size A4; SheetNumber: 1; SheetTotal: 1